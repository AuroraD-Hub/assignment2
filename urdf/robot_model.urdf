Commit message: Update robot_model.urdf

File: urdf/robot_model.urdf (robot description, URDF)
Before this commit: robot robot_xacro, 7 links, 6 joints
Links:
- link base_link: mass 10 -> 5
